<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\plasma_cut_mb1.ewp</path>
  </project>
  <batchBuild />
</workspace>
