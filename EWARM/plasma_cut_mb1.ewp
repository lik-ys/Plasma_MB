# IAR project plasma_cut_mb1.ewp, settings and files
configuration plasma_cut_mb1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include; ../Core/_Protocols/MB/include; ../Core/_Protocols/MB/port; ../Core/_Protocols/MB/app; ../Core/_Protocols/MB/ascii; ../Core/_Protocols/MB/functions; ../Core/_Protocols/MB/RTU; ../Core/_Protocols/MB/TCP; ../Core/_Protocols/MB; ../Core/_Protocols/app; ../Core/_Math
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: plasma_cut_mb1.hex
  ILINK.IlinkOutputFile: plasma_cut_mb1.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/_Protocols/MB/include; ../Core/_Protocols/MB/port; ../Core/_Protocols/MB/app; ../Core/_Protocols/MB/ascii; ../Core/_Protocols/MB/functions; ../Core/_Protocols/MB/RTU; ../Core/_Protocols/MB/TCP; ../Core/_Protocols/MB; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/system/arch; ../Middlewares/Third_Party/LwIP/src/include/; ../LWIP/App; ../LWIP/Target; ../Drivers/BSP/Components/dp83848/
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: config.h
    ../Core/Src/: io_process.c StateMashine.cpp main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Core/_Protocols/_MB
    ../Core/_Protocols/MB/: mb.c mb_com.cpp mb_m.c
  group Application/User/Core/_Protocols/_MB/app
    ../Core/_Protocols/MB/app/: user_mb_app.c user_mb_app_m.c
  group Application/User/Core/_Protocols/_MB/ascii
    ../Core/_Protocols/MB/ascii/: mbascii.c
  group Application/User/Core/_Protocols/_MB/functions
    ../Core/_Protocols/MB/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
  group Application/User/Core/_Protocols/_MB/include
    ../Core/_Protocols/MB/include/: mb.h mb_m.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Application/User/Core/_Protocols/_MB/port
    ../Core/_Protocols/MB/port/: portcritical.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
  group Application/User/Core/_Protocols/_MB/RTU
    ../Core/_Protocols/MB/RTU/: mbcrc.c mbrtu.c mbrtu_m.c
  group Application/User/Core/_Protocols/_MB/TCP
    ../Core/_Protocols/MB/TCP/: mbtcp.c
  group Application/User/Math
    ../Core/_Math/: Filters.c Sorting.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
